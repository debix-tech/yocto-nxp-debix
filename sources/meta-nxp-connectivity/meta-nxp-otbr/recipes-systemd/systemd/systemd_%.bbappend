FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Patch-to-allow-creating-Address-and-Route-when-RA-is.patch"
