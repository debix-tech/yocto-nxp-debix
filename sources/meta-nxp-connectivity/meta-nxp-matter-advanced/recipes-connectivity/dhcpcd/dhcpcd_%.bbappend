FILESEXTRAPATHS:append := "${THISDIR}/files:"

SYSTEMD_AUTO_ENABLE = "disable"
